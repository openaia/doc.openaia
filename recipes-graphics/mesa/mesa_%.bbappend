PACKAGECONFIG:append:rk3288 = " kmsro panfrost"
PACKAGECONFIG:append:rk3399 = " kmsro panfrost"
PACKAGECONFIG:append:rock64 = " kmsro lima"
